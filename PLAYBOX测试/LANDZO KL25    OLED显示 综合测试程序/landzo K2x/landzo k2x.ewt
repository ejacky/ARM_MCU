<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>KL25_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>KL25_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>KL26_Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>KL26_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\src\App\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\App\main.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\adc\KL2x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\delay\KL2x_delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\dma\KL2x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\Flash\KL2x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\gpio\KL2x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\i2c\KL2x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\lptmr\KL2x_lptmr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\PIT\KL2x_PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\spi\KL2x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\TPM\KL2x_TPM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\uart\KL2x_uart.c</name>
    </file>
  </group>
  <group>
    <name>Include</name>
    <file>
      <name>$PROJ_DIR$\..\src\common\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common\include.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\gpio\pin_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\system\systemclock.h</name>
    </file>
  </group>
  <group>
    <name>Landzo Module</name>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Calculation\Landzo_Calculation.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_CCD\Landzo_CCD.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Electromagnetism\Landzo_Electromagnetism.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_GyroAccelerate\Landzo_GyroAccelerate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Key\Landzo_Key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_MeasureSpeed\Landzo_MeasureSpeed.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Motor\Landzo_Motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_OLED\Landzo_OLED.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Predator\Landzo_Predator.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_ServoMotor\Landzo_ServoMotor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_TFTLCD\Landzo_TFTLCD.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\landzo\Landzo_Ultrasonic\Landzo_Ultrasonic.c</name>
    </file>
  </group>
  <group>
    <name>System</name>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\arm_cm0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\crt0.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\start.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Driver\system\system.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cpu\vectors.c</name>
    </file>
  </group>
</project>


